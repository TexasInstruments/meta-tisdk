SRC_URI = "git://git.ti.com/git/graphics/ti-gc320-driver.git;protocol=https;branch=${BRANCH} \
          file://0001-km-Fix-stdarg-header-file-compilation-issues.patch \
          file://0002-km-import-DMA_BUF-namespace-to-load-the-dma_buf-modu.patch"

