PR:append = "_tisdk_0"

UTILS:append:ti33x = " \
    opencv-dev \
"

UTILS:append:ti43x = " \
    opencv-dev \
"

