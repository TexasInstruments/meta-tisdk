RDEPENDS:${PN}:append = " \
        libdrm-dev \
        websocketd \
        libloki \
        boost \
        json-c \
"

PR:append = "_tisdk_0"
