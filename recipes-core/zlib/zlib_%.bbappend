FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Avoid-compiler-complaints-if-_TIME_BITS-defined-when.patch"
