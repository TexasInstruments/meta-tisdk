PR:append = "_tisdk_0"

TEST_LIST += "\
    ptp \
    timers \
"
