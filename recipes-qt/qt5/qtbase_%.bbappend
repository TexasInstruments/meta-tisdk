PACKAGECONFIG:append:k3 = " xkbcommon"

PR:append = ".tisdk0"

