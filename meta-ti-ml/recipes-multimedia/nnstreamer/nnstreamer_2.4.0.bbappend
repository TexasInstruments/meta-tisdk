FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-decoder-Do-not-clear-properties_table-in-BoundingBox.patch"

