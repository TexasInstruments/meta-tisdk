SRCREV:tie-jailhouse:bsp-ti-6_18 = "aae8d5ac33fc27dc364c3ac1c41b71c7bdcda726"

PR:append = "_tisdk_0"
