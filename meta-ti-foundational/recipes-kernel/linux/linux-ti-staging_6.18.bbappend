SRCREV:tie-jailhouse:bsp-ti-6_18 = "0dae10194f6a69082261e9f135a5acb51a2eb9cb"

PR:append = "_tisdk_0"
