PR:append = "_tisdk_1"

PACKAGE_INSTALL += "jailhouse-oob perf"
