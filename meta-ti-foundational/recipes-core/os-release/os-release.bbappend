# Append TISDK_VERSION to /etc/os-release
# Value comes from meta-ti-foundational/conf/tisdk-release.conf
OS_RELEASE_FIELDS:append = " TISDK_VERSION"
