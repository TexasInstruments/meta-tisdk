SRCREV_uboot:tie-jailhouse:bsp-ti-6_18 = "5351af7d65d0d722a006a6671d843b77f7ff291a"

PR:append = "_tisdk_0"
