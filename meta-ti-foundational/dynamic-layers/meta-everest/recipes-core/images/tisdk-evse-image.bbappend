# Only installed when the meta-everest layer is present (see BBFILES_DYNAMIC
# in conf/layer.conf).
IMAGE_INSTALL:append = " \
    everest-core \
"
