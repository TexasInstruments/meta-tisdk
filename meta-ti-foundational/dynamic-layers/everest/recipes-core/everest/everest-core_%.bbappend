
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PR:append = "_tisdk_0"
