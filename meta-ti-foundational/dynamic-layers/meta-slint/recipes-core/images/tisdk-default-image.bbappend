IMAGE_INSTALL:append = " slint-demos slint-viewer liberation-fonts"

PR:append = "_tisdk_0"
