# For AM62L (no GPU), remove OpenGL demos that require GPU
SLINT_EXAMPLES:remove:am62lxx = "opengl_texture opengl_underlay"
